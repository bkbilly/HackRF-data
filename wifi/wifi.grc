<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>bkbilly</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>WiFi Spectrum Analysis</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>6</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>max</key><value>12</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>12</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>2412e6 + (5e6 * (channel - 1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>RTL820T_0</value></param>
<param><key>bb_gain0</key><value>15</value></param>
<param><key>freq0</key><value>frequency</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>15</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>grid_pos</key><value>0, 0, 4, 5</value></param>
<param><key>labels</key><value>['Spectrum', 'Waterfall']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0, 0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>575, 600</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>5120</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0, 1</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>575, 600</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>RTL820T_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RTL820T_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
